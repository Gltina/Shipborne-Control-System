# Keil uVision project ShipborneControlSystem.uvprojx, settings and files
target master (6160000::V6.16::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ShipborneControlSystem +hex
  c flags: Optim=2 OneElfS=1 v6Lang=4 v6LangP=3 wLevel=3
  c include: D:\Program Files\Keil_v5\ARM\Packs\Keil\STM32F1xx_DFP\2.3.0\Device\Include;D:\Program Files\Keil_v5\ARM\Packs\Keil\STM32F1xx_DFP\2.3.0\Device\StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group code
    ./: main.c stm32f10x_it.c stm32f10x_it.h
    ./DS18B20/: ds18b20.c ds18b20.h
    ./I2C/: i2c.c i2c.h
    ./MPU6050/: mpu6050.c mpu6050.h
    ./USART/: usart.c usart.h
    ./DeviceManage/: deviceManage.c deviceManage.h
    ./LED/: led.c led.h
    ./SRF05/: srf05.c srf05.h
    ./delay/: delay.c delay.h
    ./Algorithm/: algorithm.c algorithm.h
    ./WaterTank/: waterTank.c waterTank.h
    ./WaterPress/: waterPress.c waterPress.h
    ./SendingEnd/: sendingEnd.c sendingEnd.h
    ./Engine755/: engine775.c engine775.h
    ./RudderControl/: rudderControl.c rudderControl.h
software components: CMSIS:CORE 5.5.0, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, CMSIS Driver:I2C 2.1, CMSIS Driver:USART 2.3, Device:DMA 1.2, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DAC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
